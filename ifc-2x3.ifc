Properties of the parts of a building model (IFC2X3)

# File
Description: Schutzwendel, 200 mm, Stahl vernickelt, Durchmesser InnenxAußen 11 x 17 mm, Leitungseinführung 7,8 mm, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: C1809219, Schutzwendel, 200 mm, Stahl vernickelt, Durchmesser InnenxAußen 11 x 17 mm, Leitungseinführung 7,8 mm
In: Raum
Description: Schutzwendel für Kanaleinbau für Kapillarregler und Hülsen- sowie Kabelfühler. 200 mm, Stahl vernickelt, Durchmesser Innen x Außen 11 x 17 mm, Leitungseinführung 7,8mm; Classification: EC010502 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: C1809219; ModelLabel: SW-200; GlobalTradeItemNumber: 4050528018205; ProductURL: https://alre.de/produkt_C1809219
Pset_Specification - NominalLength: 0.215 m; NominalWidth: 0.08 m; NominalDepth: 0.04 m; NetWeight: 0.119
Pset_ALRE_ETIM_Properties - Außendurchmesser: 17; Innendurchmesser: 7.8; Material Tauchrohr: rostfreier Stahl; Einstecklänge: 200; ETIM-Klasse: EC010502; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-C1809219.pdf
